# Keil uVision project eeprom.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC11F60XE STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: eeprom
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: eeprom.c
